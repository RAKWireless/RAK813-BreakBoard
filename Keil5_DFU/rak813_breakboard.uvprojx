# Keil uVision project rak813_breakboard.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rak813_breakboard +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_CUSTOM USE_APP_CONFIG NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SWI_DISABLE0 CONFIG_GPIO_AS_PINRESET REGION_EU868
  c include: ..\Apps;..\Board;..\Board\lora_board;..\Board\peripherals;..\LoRa_Lib\mac;..\LoRa_Lib\mac\region;..\LoRa_Lib\radio;..\LoRa_Lib\radio\sx1276;..\LoRa_Lib\system;..\LoRa_Lib\system\crypto;..\nRF_Lib\external\fprintf;..\nRF_Lib\external\segger_rtt;..\nRF_Lib\components\boards;..\nRF_Lib\components\device;..\nRF_Lib\components\ble\ble_services\ble_nus;..\nRF_Lib\components\toolchain;..\nRF_Lib\components\softdevice\common;..\nRF_Lib\components\softdevice\s132\headers;..\nRF_Lib\components\softdevice\s132\headers\nrf52;..\nRF_Lib\components\drivers_nrf\clock;..\nRF_Lib\components\drivers_nrf\common;..\nRF_Lib\components\drivers_nrf\gpiote;..\nRF_Lib\components\drivers_nrf\rtc;..\nRF_Lib\components\drivers_nrf\spi_master;..\nRF_Lib\components\drivers_nrf\timer;..\nRF_Lib\components\drivers_nrf\uart;..\nRF_Lib\components\drivers_nrf\twi_master;..\nRF_Lib\components\libraries\balloc;..\nRF_Lib\components\libraries\bsp;..\nRF_Lib\components\libraries\util;..\nRF_Lib\components\libraries\button;..\nRF_Lib\components\libraries\experimental_log;..\nRF_Lib\components\libraries\experimental_memobj;..\nRF_Lib\components\libraries\fds;..\nRF_Lib\components\libraries\fifo;..\nRF_Lib\components\libraries\fstorage;..\nRF_Lib\components\libraries\uart;..\nRF_Lib\components\libraries\experimental_section_vars;..\nRF_Lib\components\drivers_nrf\hal;..\nRF_Lib\components\libraries\strerror;..\nRF_Lib\components\libraries\experimental_log\src;..\nRF_Lib\components\libraries\timer;..\nRF_Lib\components\drivers_nrf\delay;..\nRF_Lib\components\libraries\atomic;..\nRF_Lib\components\libraries\pwr_mgmt;..\nRF_Lib\components\ble\common;..\nRF_Lib\components\libraries\mutex;..\nRF_Lib\components\ble\ble_advertising;..\nRF_Lib\components\drivers_nrf\wdt;..\nRF_Lib\components\ble\nrf_ble_gatt;..\nRF_Lib\components\libraries\mem_manager;..\nRF_Lib\components\ble\ble_db_discovery;..\nRF_Lib\components\ble\peer_manager;..\nRF_Lib\components\libraries\atomic_fifo;..\nRF_Lib\components\libraries\crc16;..\nRF_Lib\components\ble\ble_services\ble_dfu;..\nRF_Lib\components\libraries\bootloader\dfu;..\nRF_Lib\components\libraries\svc
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x5d000
  memory RVCT9: RAM 0x20002a68 size 0xd598
  link misc: --diag_suppress 6330
  group Apps
    ../Apps/: sdk_config.h Commissioning.h
    ./: main.c
  group Board
    ../nRF_Lib/components/boards/: boards.c
    ../nRF_Lib/components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
    ../nRF_Lib/components/toolchain/arm/: arm_startup_nrf52.s
    ../nRF_Lib/components/toolchain/: system_nrf52.c
  group Board/lora_board
    ../Board/lora_board/: board.c gpio-board.c rtc-board.c spi-board.c sx1276-board.c timer.c utilities.c utils.c
  group Board/peripherals
    ../Board/peripherals/: rak_i2c_sht31.c rak_spi_drv.c lis3dh_driver.c rak_i2c_drv.c rak_i2c_gps_max7.c rak_i2c_lis3dh.c rak_i2c_oled.c
  group LoRa_Lib/mac
    ../LoRa_Lib/mac/: LoRaMac.c LoRaMacCrypto.c
  group LoRa_Lib/mac/region
    ../LoRa_Lib/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCommon.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c RegionCN470.c RegionCN779.c RegionEU433.c
  group LoRa_Lib/radio
    ../LoRa_Lib/radio/sx1276/: sx1276.c
  group LoRa_Lib/system
    ../LoRa_Lib/system/crypto/: aes.c cmac.c
    ../LoRa_Lib/system/: gps.c
  group nRF_Lib/ble
    ../nRF_Lib/components/ble/ble_advertising/: ble_advertising.c
    ../nRF_Lib/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../nRF_Lib/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../nRF_Lib/components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../nRF_Lib/components/ble/ble_services/ble_nus/: ble_nus.c
    ../nRF_Lib/components/ble/ble_db_discovery/: ble_db_discovery.c
  group nRF_Lib/DFU
    ../nRF_Lib/components/ble/ble_services/ble_dfu/: ble_dfu.c ble_dfu_bonded.c ble_dfu_unbonded.c
    ../nRF_Lib/components/libraries/bootloader/dfu/: nrf_dfu_svci.c
  group nRF_Lib/device_nrf
    ../nRF_Lib/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../nRF_Lib/components/drivers_nrf/common/: nrf_drv_common.c
    ../nRF_Lib/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../nRF_Lib/components/drivers_nrf/rtc/: nrf_drv_rtc.c
    ../nRF_Lib/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../nRF_Lib/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../nRF_Lib/components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Lib/libraries
    ../nRF_Lib/components/libraries/button/: app_button.c
    ../nRF_Lib/components/libraries/fifo/: app_fifo.c
    ../nRF_Lib/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../nRF_Lib/components/libraries/fds/: fds.c
    ../nRF_Lib/components/libraries/uart/: app_uart_fifo.c retarget.c
    ../nRF_Lib/components/libraries/strerror/: nrf_strerror.c
    ../nRF_Lib/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../nRF_Lib/components/libraries/experimental_memobj/: nrf_memobj.c
    ../nRF_Lib/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../nRF_Lib/components/libraries/balloc/: nrf_balloc.c
    ../nRF_Lib/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../nRF_Lib/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c sdk_mapped_flags.c nrf_assert.c
    ../nRF_Lib/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../nRF_Lib/components/libraries/timer/: app_timer.c
    ../nRF_Lib/components/libraries/scheduler/: app_scheduler.c
    ../nRF_Lib/components/libraries/crc16/: crc16.c
  group nRF_Lib/log
    ../nRF_Lib/components/libraries/experimental_log/src/: nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c nrf_log_backend_rtt.c nrf_log_backend_serial.c
  group nRF_Lib/segger_RTT
    ../nRF_Lib/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group nRF_Lib/softdevice
    ../nRF_Lib/components/softdevice/common/: nrf_sdh_soc.c nrf_sdh.c nrf_sdh_ble.c
